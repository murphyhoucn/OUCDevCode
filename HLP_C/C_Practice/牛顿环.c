#include <stdio.h>
#define N 20

int main(void)
{
	double a[N] =
	{
		26.77,
		26.69,
		26.62,
		26.51,
		26.48,
		26.42,
		26.36,
		26.28,
		26.21,
		26.14,
		26.06,
		25.98,
		25.91,
		25.83,
		25.73,
		25.61,
		25.65,
		25.46,
		25.38,
		25.28,

	};

	double b[N] =
	{
		18.73,
		18.80,
		18.86,
		18.92,
		18.99,
		19.07,
		19.15,
		19.21,
		19.28,
		19.36,
		19.45,
		19.52,
		19.60,
		19.69,
		19.77,
		19.86,
		19.97,
		20.04,
		20.13,
		20.23
	};

	
	int i;
	printf("r:\n");
	for (i = 0; i < N; i++)
	{
		printf("%d:%.3lf\n", i + 1, a[i] - b[i]);
	}

	printf("r:\n");
	for (i = 0; i < N; i++)
	{
		printf("%d:%.2lf\n", i + 1, (a[i] - b[i])*(a[i] - b[i]));
	}

	printf("r:\n");
	for (i = 0; i < N/2; i++)
	{
		printf("%d:%.2lf\n", i + 1, ((a[i] - b[i])*(a[i] - b[i]))- ((a[i+10] - b[i+10])*(a[i+10] - b[i+10])));
	}

	double c[N / 2];
	for (i = 0; i < N / 2; i++)
	{
		c[i] = (((a[i] - b[i])*(a[i] - b[i])) - ((a[i + 10] - b[i + 10])*(a[i + 10] - b[i + 10])));
	}

	double sum = 0.0;
	for (i = 0; i < N / 2; i++)
	{
		sum+=(((a[i] - b[i])*(a[i] - b[i])) - ((a[i + 10] - b[i + 10])*(a[i + 10] - b[i + 10])));
	}
	printf("average=%.3lf", sum / 10);




	return 0;
}